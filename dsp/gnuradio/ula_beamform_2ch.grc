options:
  parameters:
    author: markus
    generate_options: qt_gui
    id: ula_beamform_2ch
    output_language: python
    title: ULA beamforming 2 ch
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: initial_fc
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: phase_diff
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: phase_diff*180/__import__("math").pi
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: initial_fc
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: initial_fc
    center_freq1: initial_fc
    clock_rate: 200e6
    clock_source0: internal
    clock_source1: internal
    dev_addr: '"addr1=192.168.10.2,addr0=192.168.10.3"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    num_mboards: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_const_source_x_0_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [uhd_usrp_source_0, '0', blocks_add_xx_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
