options:
  parameters:
    author: markus
    generate_options: no_gui
    id: capture_data
    output_language: python
    run_options: run
    title: Capture data
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '34'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/markus/uni/esd5_project/dsp/measured_data/good_shit_30_degrees_3
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: 200e6
    clock_source0: internal
    dev_addr: '"addr0=192.168.10.2"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=192.168.10.3,addr1=192.168.10.4"'
    dev_args: '""'
    gain0: gain
    gain1: gain-6
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_interleave_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', blocks_interleave_0, '0']
- [uhd_usrp_source_0, '1', blocks_interleave_0, '1']
- [uhd_usrp_source_0_0, '0', blocks_interleave_0, '2']
- [uhd_usrp_source_0_0, '1', blocks_interleave_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
