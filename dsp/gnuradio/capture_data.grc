options:
  parameters:
    author: markus
    generate_options: no_gui
    id: capture_data
    output_language: python
    run_options: run
    title: Capture data
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: ang
  id: variable
  parameters:
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '34'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5.12e6
  states: {}
- name: try_num
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f"/home/markus/uni/esd5_project/dsp/satimo/{ang}_degrees_{try_num}"
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    dev_addr: '"addr0=192.168.10.100"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_interleave_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0_1, '0', blocks_interleave_0, '0']
- [uhd_usrp_source_0_1, '1', blocks_interleave_0, '1']
- [uhd_usrp_source_0_1, '2', blocks_interleave_0, '2']
- [uhd_usrp_source_0_1, '3', blocks_interleave_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
