options:
  parameters:
    category: Custom
    description: Tune a UHD source from a QT sink via messages (double-click a frequency to tune)
    generate_options: qt_gui
    id: uhd_tune_msg
    output_language: python
    title: UHD Message Tuner
  states: {}

blocks:
- name: ant_msg
  id: variable_qtgui_chooser
  parameters:
    label: Antenna
    num_opts: '2'
    option0: TX/RX
    option1: RX2
    type: string
    value: TX/RX
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: cmd_msg
  id: variable
  parameters:
    value: 'pmt.to_pmt({''antenna'': ant_msg, ''gain'': gain_msg, ''chan'': 0, ''freq'': freq_msg, ''lo_offset'': lo_msg})'
  states: {}
- name: freq_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency
    type: real
    value: initial_fc
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: gain_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Gain
    type: real
    value: gain
  states: {}
- name: initial_fc
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: lo_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: LO Offset
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: cmd_msg
    period: '2000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: initial_fc
    center_freq1: initial_fc
    clock_rate: 200e6
    dev_addr: '"addr1=192.168.10.2,addr0=192.168.10.3"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, qtgui_sink_x_0, freq]
- [blocks_message_strobe_0, strobe, qtgui_sink_x_0_0, freq]
- [blocks_message_strobe_0, strobe, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '1', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
