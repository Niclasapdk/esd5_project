options:
  parameters:
    author: markus
    generate_options: qt_gui
    id: reference_implementation_ula_beamscan_2ch
    output_language: python
    title: Beamscan spatial spectrum estimation
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.44e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '53'
  states: {}
- name: in_snr
  id: variable
  parameters:
    value: '20'
  states: {}
- name: phi_scan_max
  id: variable
  parameters:
    value: '50'
  states: {}
- name: phi_scan_min
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: phi_step
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5.12e6
  states: {}
- name: snapshot_count
  id: variable
  parameters:
    value: '8'
  states: {}
- name: spectrum_len
  id: variable
  parameters:
    value: 1+(phi_scan_max-phi_scan_min)//phi_step
  states: {}
- name: targets
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_2
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f"/home/markus/uni/esd5_project/dsp/simulation_data/results_cbf_py/{targets}_targets_{snapshot_count}_snapshots_{in_snr}dB_snr.raw"
    type: float
    vlen: spectrum_len
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: f"/home/markus/uni/esd5_project/dsp/simulation_data/results_mvdr_py/{targets}_targets_{snapshot_count}_snapshots_{in_snr}dB_snr.raw"
    type: float
    vlen: spectrum_len
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/markus/uni/esd5_project/dsp/satimo/data_4th_try
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: f"/home/markus/uni/esd5_project/dsp/simulation_data/ula_4ch_sim_data_{targets}_targets_{in_snr}dB_snr.raw"
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/markus/uni/esd5_project/dsp/measured_data/-20_degrees_3
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/markus/uni/esd5_project/dsp/measured_data/satimo/data_try2
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '4'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):
          """Beamscan spatial spectrum estimator for 4 channel ULA"""

          def __init__(self, num_samples=51, signal_freq=2.44e9, array_d=0.5, phi_scan_min=-50, phi_scan_max=50, phi_step=2, rx1_phase_cal=0, rx2_phase_cal=0, rx3_phase_cal=0, rx4_phase_cal=0):
              """arguments to this function show up as parameters in GRC"""
              # must change default phi values to pass static vector_len checks (goofy but that's how gnuradio is)
              self.spectrum_len = 1+(phi_scan_max-phi_scan_min)//phi_step
              gr.basic_block.__init__(
                  self,
                  name='Beamscan spatial spectrum estimator',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64, np.complex64, np.complex64],
                  out_sig=[(np.float32, self.spectrum_len), np.float32, np.float32]
              )
              self.logger = gr.logger(self.alias())
              self.num_samples = num_samples
              self.signal_freq = signal_freq
              self.steering_step = phi_step
              self.d = array_d
              self.c = 299792458
              self.lambda_ = self.c / self.signal_freq
              self.steering_angles = np.arange(phi_scan_min, phi_scan_max+1, phi_step)
              steervec = lambda n, cal: np.exp(-1j * (np.pi * n * np.sin(np.deg2rad(self.steering_angles)) + np.deg2rad(cal)))
              self.win = np.hamming(self.num_samples)
              self.rx1_phase_cal = rx1_phase_cal
              self.rx2_phase_cal = rx2_phase_cal
              self.rx3_phase_cal = rx3_phase_cal
              self.rx4_phase_cal = rx4_phase_cal
              self.logger.info(f"creating block with spectrum length {self.spectrum_len}")
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.steering_vectors = np.asarray([
                      steervec(0, self.rx1_phase_cal),
                      steervec(1, self.rx2_phase_cal),
                      steervec(2, self.rx3_phase_cal),
                      steervec(3, self.rx4_phase_cal)]).transpose() # e^{-j*phase_shift}
              # transpose steering vector array so indexing is (phi, antenna)
              self.logger.info(f"steering_vectors: {self.steering_vectors}")

          def general_work(self, input_items, output_items):
              for i in range(4):
                  if len(input_items[i]) < self.num_samples:
                      return 0
              signals_in = np.asarray([input_items[0][:self.num_samples],
                                       input_items[1][:self.num_samples],
                                       input_items[2][:self.num_samples],
                                       input_items[3][:self.num_samples]])
              steervecs = self.steering_vectors
              sig_beamformed = np.matmul(steervecs, signals_in) # dimension: phi X snapshot
              spectrum = np.mean(np.square(np.abs(sig_beamformed)), axis=1).astype("float32")
              peak_value = np.max(spectrum).astype("float32")
              doa = self.steering_angles[np.argmax(spectrum)]
              output_items[0][:] = spectrum
              output_items[1][:] = doa
              output_items[2][:] = peak_value
              for i in range(4):
                  self.consume(i, self.num_samples)
              return len(output_items[0])
    array_d: '0.5'
    num_samples: snapshot_count
    phi_scan_max: phi_scan_max
    phi_scan_min: phi_scan_min
    phi_step: phi_step
    rx1_phase_cal: '0'
    rx2_phase_cal: '0'
    rx3_phase_cal: '0'
    rx4_phase_cal: '0'
    signal_freq: 2.44e9
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):
          """MVDR spatial spectrum estimator for 4 channel ULA"""

          def __init__(self, num_samples=16, signal_freq=2.44e9, array_d=0.5, phi_scan_min=-50, phi_scan_max=50, phi_step=2, rx1_phase_cal=0, rx2_phase_cal=0, rx3_phase_cal=0, rx4_phase_cal=0):
              """arguments to this function show up as parameters in GRC"""
              # must change default phi values to pass static vector_len checks (goofy but that's how gnuradio is)
              self.spectrum_len = 1+(phi_scan_max-phi_scan_min)//phi_step
              gr.basic_block.__init__(
                  self,
                  name='MVDR spatial spectrum estimator',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64, np.complex64, np.complex64],
                  out_sig=[(np.float32, self.spectrum_len), np.float32, np.float32]
              )
              self.logger = gr.logger(self.alias())
              self.num_samples = num_samples
              self.signal_freq = signal_freq
              self.steering_step = phi_step
              self.d = array_d
              self.c = 299792458
              self.lambda_ = self.c / self.signal_freq
              self.steering_angles = np.arange(phi_scan_min, phi_scan_max+1, phi_step)
              steervec = lambda n, cal: np.exp(-1j * (np.pi * n * np.sin(np.deg2rad(self.steering_angles)) + np.deg2rad(cal)))
              self.win = np.hamming(self.num_samples)
              self.rx1_phase_cal = rx1_phase_cal
              self.rx2_phase_cal = rx2_phase_cal
              self.rx3_phase_cal = rx3_phase_cal
              self.rx4_phase_cal = rx4_phase_cal
              self.logger.info(f"creating block with spectrum length {self.spectrum_len}")
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.steering_vectors = np.asarray([
                      steervec(0, self.rx1_phase_cal),
                      steervec(1, self.rx2_phase_cal),
                      steervec(2, self.rx3_phase_cal),
                      steervec(3, self.rx4_phase_cal)]).transpose() # e^{-j*phase_shift}
              # transpose steering vector array so indexing is (phi, antenna)
              self.logger.info(f"steering_vectors: {self.steering_vectors}")

          def general_work(self, input_items, output_items):
              for i in range(4):
                  if len(input_items[i]) < self.num_samples:
                      return 0
              signals_in = np.asmatrix(np.asarray([input_items[0][:self.num_samples],
                                       input_items[1][:self.num_samples],
                                       input_items[2][:self.num_samples],
                                       input_items[3][:self.num_samples]]).T)
              R = (signals_in.H @ signals_in) / self.num_samples
              R_inv = np.linalg.inv(R)
              spectrum = np.zeros(self.spectrum_len)
              for i in range(self.spectrum_len):
                  s = np.asmatrix(self.steering_vectors[i]).T
                  w = R_inv @ (s / (s.H @ R_inv @ s));
                  sig_mvdr = signals_in @ w
                  p_mvdr = np.mean(np.square(np.abs(sig_mvdr)), axis=0).astype(np.float32)[0,0]
                  spectrum[i] = p_mvdr

              peak_value = np.max(spectrum).astype("float32")
              doa = self.steering_angles[np.argmax(spectrum)]
              output_items[0][:] = spectrum
              output_items[1][:] = doa
              output_items[2][:] = peak_value
              for i in range(4):
                  self.consume(i, self.num_samples)
              return len(output_items[0])
    array_d: '0.5'
    num_samples: snapshot_count
    phi_scan_max: '50'
    phi_scan_min: '-50'
    phi_step: '2'
    rx1_phase_cal: '0'
    rx2_phase_cal: '0'
    rx3_phase_cal: '0'
    rx4_phase_cal: '0'
    signal_freq: '2440000000.0'
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"CBF"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"MVDR"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '360'
    ymin: '-360'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    name: '"CBF"'
    vlen: spectrum_len
    x_axis_label: '"Steering angle"'
    x_start: phi_scan_min
    x_step: phi_step
    x_units: '"degrees"'
    y_axis_label: '"Power"'
    ymax: '5'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    name: '"MVDR"'
    vlen: spectrum_len
    x_axis_label: '"Steering angle"'
    x_start: phi_scan_min
    x_step: phi_step
    x_units: '"degrees"'
    y_axis_label: '"Power"'
    ymax: '5'
    ymin: '0'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: 200e6
    clock_source0: internal
    dev_addr: '"addr0=192.168.10.2"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=192.168.10.3,addr1=192.168.10.4"'
    dev_args: '""'
    gain0: gain
    gain1: gain-6
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: pc_clock
    time_source0: external
    time_source1: external
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    clock_source0: internal
    dev_addr: '"addr0=192.168.10.100"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: '90'
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0_0_0, '0']
- [blocks_complex_to_magphase_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_complex_to_magphase_0_0, '1', blocks_sub_xx_0_0_0, '1']
- [blocks_complex_to_magphase_0_1, '0', blocks_null_sink_0_1, '0']
- [blocks_complex_to_magphase_0_1, '1', blocks_sub_xx_0, '1']
- [blocks_complex_to_magphase_0_2, '0', blocks_null_sink_0_2, '0']
- [blocks_complex_to_magphase_0_2, '1', blocks_sub_xx_0_0, '1']
- [blocks_deinterleave_0, '0', epy_block_0, '0']
- [blocks_deinterleave_0, '0', epy_block_1, '0']
- [blocks_deinterleave_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_deinterleave_0, '1', epy_block_0, '1']
- [blocks_deinterleave_0, '1', epy_block_1, '1']
- [blocks_deinterleave_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_deinterleave_0, '2', epy_block_0, '2']
- [blocks_deinterleave_0, '2', epy_block_1, '2']
- [blocks_deinterleave_0, '2', qtgui_time_sink_x_0, '2']
- [blocks_deinterleave_0, '3', epy_block_0, '3']
- [blocks_deinterleave_0, '3', epy_block_1, '3']
- [blocks_deinterleave_0, '3', qtgui_time_sink_x_0, '3']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle2_0, '0']
- [blocks_interleave_0, '0', blocks_file_sink_0_1, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_sub_xx_0_0_0, '0', qtgui_time_sink_x_2, '2']
- [blocks_throttle2_0, '0', blocks_deinterleave_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_0, '1', qtgui_time_sink_x_1, '0']
- [epy_block_0, '2', qtgui_time_sink_x_1, '1']
- [epy_block_1, '0', blocks_file_sink_0_0, '0']
- [epy_block_1, '0', qtgui_vector_sink_f_0_0, '0']
- [epy_block_1, '1', qtgui_time_sink_x_1_0, '0']
- [epy_block_1, '2', qtgui_time_sink_x_1_0, '1']
- [uhd_usrp_source_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '1', epy_block_0, '1']
- [uhd_usrp_source_0, '1', epy_block_1, '1']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0, '1']
- [uhd_usrp_source_0_0, '0', epy_block_0, '2']
- [uhd_usrp_source_0_0, '0', epy_block_1, '2']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0, '2']
- [uhd_usrp_source_0_0, '1', epy_block_0, '3']
- [uhd_usrp_source_0_0, '1', epy_block_1, '3']
- [uhd_usrp_source_0_0, '1', qtgui_time_sink_x_0, '3']
- [uhd_usrp_source_0_1, '0', blocks_complex_to_magphase_0, '0']
- [uhd_usrp_source_0_1, '0', blocks_interleave_0, '0']
- [uhd_usrp_source_0_1, '0', epy_block_0, '0']
- [uhd_usrp_source_0_1, '0', epy_block_1, '0']
- [uhd_usrp_source_0_1, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0_1, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0_1, '1', blocks_complex_to_magphase_0_1, '0']
- [uhd_usrp_source_0_1, '1', blocks_interleave_0, '1']
- [uhd_usrp_source_0_1, '1', epy_block_0, '1']
- [uhd_usrp_source_0_1, '1', epy_block_1, '1']
- [uhd_usrp_source_0_1, '1', qtgui_const_sink_x_0, '1']
- [uhd_usrp_source_0_1, '1', qtgui_time_sink_x_0, '1']
- [uhd_usrp_source_0_1, '2', blocks_complex_to_magphase_0_2, '0']
- [uhd_usrp_source_0_1, '2', blocks_interleave_0, '2']
- [uhd_usrp_source_0_1, '2', epy_block_0, '2']
- [uhd_usrp_source_0_1, '2', epy_block_1, '2']
- [uhd_usrp_source_0_1, '2', qtgui_const_sink_x_0, '2']
- [uhd_usrp_source_0_1, '2', qtgui_time_sink_x_0, '2']
- [uhd_usrp_source_0_1, '3', blocks_complex_to_magphase_0_0, '0']
- [uhd_usrp_source_0_1, '3', blocks_interleave_0, '3']
- [uhd_usrp_source_0_1, '3', epy_block_0, '3']
- [uhd_usrp_source_0_1, '3', epy_block_1, '3']
- [uhd_usrp_source_0_1, '3', qtgui_const_sink_x_0, '3']
- [uhd_usrp_source_0_1, '3', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
